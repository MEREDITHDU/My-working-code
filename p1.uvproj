# Keil uVision project p1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: p1 +hex
  AfterMake: xc2 -h .\objects\p1.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p1.asm
